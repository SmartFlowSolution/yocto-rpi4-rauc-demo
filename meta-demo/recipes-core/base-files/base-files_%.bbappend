FILESEXTRAPATHS:prepend:rpi := "${THISDIR}/files:"

dirs755 += "/data"
