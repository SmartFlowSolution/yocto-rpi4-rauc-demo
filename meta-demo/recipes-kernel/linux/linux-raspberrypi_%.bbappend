FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://tun.cfg \
            file://netfilter.cfg"
